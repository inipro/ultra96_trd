deltask do_package_write_rpm_setscene
